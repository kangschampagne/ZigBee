<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TestApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>TestApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>TestApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>TestApp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>TestApp</project>
        <configuration>CoordinatorEB-Pro</configuration>
      </member>
      <member>
        <project>TestApp</project>
        <configuration>RouterEB-Pro</configuration>
      </member>
      <member>
        <project>TestApp</project>
        <configuration>EndDeviceEB-Pro</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


